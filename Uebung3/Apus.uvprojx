# Keil uVision project Apus.uvprojx, settings and files
target Apus (6220000::V6.22::ARMCLANG)
  device: STM32F072VBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Apus
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: STM32F072,USE_STDPERIPH_DRIVER
  c include: .\src;.\stm32f0-stdperiph;.\src\Devices;.\src\Tasks
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group BSP
    ./src/BSP/: Key.c Led.c TftDisplay.c Adc.c systick.c Debug.c
  group OS
    ./src/: main.c APOS.c APOS.s
  group ST-Lib
    ./stm32f0-stdperiph/: stm32f0xx_adc.c stm32f0xx_gpio.c stm32f0xx_rcc.c
  group Devices
    ./src/Devices/: startup_stm32f072.s system_stm32f0xx.c
  group Fonts
    ./src/Fonts/: TftFont_6x8.c TftFont_16x24.c
  group Tasks
    ./src/Tasks/: TaskCounter.c TaskKey.c TaskLed.c TaskMandelbrot.c TaskPoti.c TaskWatch.c TestTask.c
